# IAR project GPS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C6 ST STM32F103C6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: Config; Include; Libraries\Delay; Libraries\SSD1306; Libraries\I2C; Libraries\UART; Libraries\minmea; Libraries\GPS; Libraries\STM32F10x_StdPeriph_Driver\inc; Libraries\STM32F10x_StdPeriph_Driver\src; Source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C PCF8563.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Config
    Config/: flash_config.h startup_stm32f10x_ld.s stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
  group Include
    Include/: Sys_Init.h
  group Libraries/Delay
    Libraries/Delay/: Delay.c Delay.h
  group Libraries/GPS
    Libraries/GPS/: GPS.c GPS.h
  group Libraries/I2C
    Libraries/I2C/: I2C.c I2C.h
  group Libraries/minmea
    Libraries/minmea/: example.c minmea.c minmea.h
  group Libraries/SSD1306
    Libraries/SSD1306/: fonts.c fonts.h ssd1306.c ssd1306.h
  group Libraries/STM32F10x_StdPeriph_Driver/inc
    Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group Libraries/STM32F10x_StdPeriph_Driver/src
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Libraries/UART
    Libraries/UART/: uart.c uart.h
  group Source
    Source/: main.c Sys_Init.c
